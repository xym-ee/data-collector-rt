# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 for Certification (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\include\socket\sys_socket;packages\wiznet-latest\inc;packages\wiznet-latest\ioLibrary;packages\wiznet-latest\ioLibrary\Ethernet;packages\wiznet-latest\ioLibrary\Internet
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: status.c udpclient.c udpserver.c
    ./: README.md
  group Devices
    ./applications/device/: light.c power.c sbus.c
  group Sensors
    ./applications/sensor/: iic_dev.c iic_distance.c gas1.c gas2.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: waitqueue.c ringbuffer.c dataqueue.c workqueue.c pipe.c completion.c ringblk_buf.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_adc.c drv_soft_i2c.c drv_usart.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: mempool.c timer.c clock.c mem.c object.c device.c thread.c irq.c components.c ipc.c scheduler.c idle.c kservice.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_qspi.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/src/: sal_socket.c
    rt-thread/components/net/sal/socket/: net_netdb.c
  group WIZnet
    packages/wiznet-latest/src/: wiz.c wiz_device.c wiz_af_inet.c wiz_socket.c wiz_ping.c
    packages/wiznet-latest/ioLibrary/Ethernet/W5500/: w5500.c
    packages/wiznet-latest/ioLibrary/Internet/DNS/: wizchip_dns.c
    packages/wiznet-latest/ioLibrary/Ethernet/: wizchip_socket.c wizchip_conf.c
    packages/wiznet-latest/ioLibrary/Internet/DHCP/: wizchip_dhcp.c
